# IAR project KL25Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; IAR; MKL25Z4; ARM_MATH_CM0PLUS
  ICCARM.CCIncludePath2: Common; CPU; Devices; Drivers; Headers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: KL25Project.out
  ILINK.IlinkIcfFile: F:\B车模\KL25_Car\Project\ConfigFiles\16KB_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: Application; Common; CPU; Devices; Drivers; Headers
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: KL25Project.srec
  ILINK.IlinkIcfFile: D:\项目\github\own\embed-smartCar\embed-smartCar\KL25_Car\Project\ConfigFiles\128KB_Pflash.icf
  group Application
    Application/: Arguments.c Arguments.h Control.c Control.h ImageProcess.c ImageProcess.h main.c OutputData.c OutputData.h
  group Common
    Common/: alloc.c common.c common.h io.c io.h printf.c startup.c startup.h typedef.h
  group CPU
    CPU/: arm_cm0.c arm_cm0.h crt0.s Fire_kinetis_MCG_CFG.h freedom.h mcg_cfg.h MKL25Z4.h start.c sysinit.c sysinit.h vectors.c vectors.h
  group Devices
    Devices/: Encoder.c Encoder.h Motor.c Motor.h OLED.c OLED.h PredatorCamera.c PredatorCamera.h PredatorCameraSCCB.c PredatorCameraSCCB.h Switch_and_Led.c Switch_and_Led.h
  group Drivers
    Drivers/: ADC.c ADC.h MCG.c MCG.h MKL_FTFA.c MKL_FTFA.h UART.c UART.h
