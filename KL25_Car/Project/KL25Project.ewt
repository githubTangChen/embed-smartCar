<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <file>
      <name>$PROJ_DIR$\Application\Arguments.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Application\Arguments.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Application\Control.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Application\Control.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Application\ImageProcess.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Application\ImageProcess.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Application\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Application\OutputData.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Application\OutputData.h</name>
    </file>
  </group>
  <group>
    <name>Common</name>
    <file>
      <name>$PROJ_DIR$\Common\alloc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Common\common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Common\common.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Common\io.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Common\io.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Common\printf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Common\startup.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Common\startup.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Common\typedef.h</name>
    </file>
  </group>
  <group>
    <name>CPU</name>
    <file>
      <name>$PROJ_DIR$\CPU\arm_cm0.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CPU\arm_cm0.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CPU\crt0.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CPU\Fire_kinetis_MCG_CFG.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CPU\freedom.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CPU\mcg_cfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CPU\MKL25Z4.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CPU\start.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CPU\sysinit.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CPU\sysinit.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CPU\vectors.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CPU\vectors.h</name>
    </file>
  </group>
  <group>
    <name>Devices</name>
    <file>
      <name>$PROJ_DIR$\Devices\Encoder.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Devices\Encoder.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Devices\Motor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Devices\Motor.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Devices\OLED.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Devices\OLED.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Devices\PredatorCamera.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Devices\PredatorCamera.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Devices\PredatorCameraSCCB.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Devices\PredatorCameraSCCB.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Devices\Switch_and_Led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Devices\Switch_and_Led.h</name>
    </file>
  </group>
  <group>
    <name>Drivers</name>
    <file>
      <name>$PROJ_DIR$\Drivers\ADC.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Drivers\ADC.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Drivers\MCG.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Drivers\MCG.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Drivers\MKL_FTFA.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Drivers\MKL_FTFA.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Drivers\UART.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Drivers\UART.h</name>
    </file>
  </group>
</project>


